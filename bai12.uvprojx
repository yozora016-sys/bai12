# Keil uVision project bai12.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\New Folder)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project12 +hex
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: main.c
software components: CMSIS:CORE 6.1.1, CMSIS:RTOS2:FreeRTOS 10.3.1, RTOS:Config 10.3.1, RTOS:Core 10.3.1, RTOS:Event Groups 10.3.1, RTOS:Heap 10.3.1, RTOS:Timers 10.3.1, Device:Startup 1.0.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0, Device:StdPeriph Drivers:USART 3.6.0
